# Keil uVision project project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: secondary +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\User\system;..\User\bsp;..\User\bsp\inc;..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User\LOGIC
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c
  group BSP
    ../User/bsp/: bsp.c bsp.h
    ../User/bsp/src/: bsp_timer.c bsp_led.c bsp_beep.c bsp_relay.c bsp_fan.c bsp_iosensor.c bsp_co2.c bsp_pm.c bsp_uart.c bsp_uart2.c bsp_uart3.c bsp_i2c_gpio.c bsp_sht30.c bsp_opt3001.c
  group SYSTEM
    ../User/system/: stm32f10x_assert.c stm32f10x_it.c sys.h
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c
  group LOGIC
    ../User/LOGIC/: uart1_cmd.c
